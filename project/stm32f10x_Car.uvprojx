# Keil uVision project stm32f10x_Car.uvprojx, settings and files
target CAR (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_Car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\FWlib\inc;..\Sys_Init\inc;..\User_Driver\inc;..\User_Prog\inc;..\system\inc;..\User_App\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USE_Driver
    ../User_Driver/src/: stm32f10x_Lora.c stm32f10x_scom.c stm32f10x_scom_it.c stm32f10x_pwmOut.c stm32f10x_CarDrive.c stm32f10x_Motor.c stm32f10x_PulseTime_it.c stm32f10x_PulseTime.c
  group USE_App
    ../User_App/src/: SHM_Car.c stm32f10x_MapSCOMandSBUS.c
  group USE_Prog
    ../User_Prog/src/: main.c taskCarCtrl.c taskComm.c taskDataPars.c
  group Sys_int
    ../Sys_Init/src/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Std_Driver
    ../FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c
  group System
    ../system/src/: device_timer.c scheduler.c time.c
